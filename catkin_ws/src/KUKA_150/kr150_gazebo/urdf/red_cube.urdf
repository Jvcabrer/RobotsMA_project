Commit message: moveit, gripper close and open poses

File: catkin_ws/src/KUKA_150/kr150_gazebo/urdf/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link base_link: mass 0.1 -> 10
